Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-09T13:21:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 09 13:21:43 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{4DE65851-4966-4BDF-A283-79C7F1A7DC60}\ifc * Database version: 5507 * Database creation date: Tue Jun 09 13:21:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 09 13:21:42 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 09 13:21:42 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1013 Washbasin faucet with washing machine valve, 1013(2020):1013 Washbasin faucet with washing machine valve:322304
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 133 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1013(2020); ConvergoRefNr: 0087-1806-0080-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: 3; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 3; VersionDate: 01/05/2020
Type - Green Building Properties(Type) - Approval KIWA SE Type Approval: 1490; Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150078767; EN Standard: EN 817; LVI Number: 6110199; RSK Number: 8277687; STF Certificate: VTT-RTH-00090-17; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/1013; URL STF: http://static.oras.com/STF/1013
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1013; Catalog Drawing URL: http://static.oras.com/catdrw/1013; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1013; FDV Document URL: http://www.oras.com/datasheet/1013/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1013; Group: Washbasin faucets; Long Marketing: Washbasin faucet with washing machine valve. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 40°-80°). Dishwasher valve for cold water. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;FIN;SWE;RUS;EST;LTU;LVA;UKR; Model: 1013 Washbasin faucet with washing machine valve; Name_en: 1013 Washbasin faucet with washing machine valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 590 x 290 x 65; Package Weight: 2.08 kg; Product Code: 1013; Product Datasheet: http://www.oras.com/datasheet/1013/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1013; Product URL: http://static.oras.com/1013; Type Name: 1013 Washbasin faucet with washing machine valve
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Connection: Copper Inlet Pipes; Connection Size: G1/2; Dishwasher Valve: Dishwasher valve; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: http://static.oras.com/manual/1013; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1 Mounting Hole; Noise Class: I (ISO 3822); Pressure Loss With Flow 01ls: 75000 Pa; Spare Parts: http://static.oras.com/sp/1013; Spout Swivel Range: 120° (40° - 80°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1013(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1013; Name: 1013 Washbasin faucet with washing machine valve; ReplacementCost: n/a; Shape: Sculptured; Size: 55x175x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1013; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1013 Washbasin faucet with washing machine valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0474425 m2; Volume: 0.00152746 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1013(2020): 1013 Washbasin faucet with washing machine valve; Family and Type: 1013(2020): 1013 Washbasin faucet with washing machine valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1013(2020): 1013 Washbasin faucet with washing machine valve; Type Id: 1013(2020): 1013 Washbasin faucet with washing machine valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
